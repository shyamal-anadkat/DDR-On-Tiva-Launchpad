# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c main.h ddr_animations.c ddr_game.c menu_nav.c arrow_printing.c arrow.c
    ../peripherals/c/: ddr_images.c
  group drivers
    ../drivers/c/: pc_buffer.c uart.c gpio_port.c timers.c i2c.c
  group peripherals
    ../peripherals/c/: serial_debug.c launchpad_io.c lcd.c lcd_images.c ps2.c eeprom.c
    ../drivers/c/: adc.c
    ./: mcp23017.c
  group ::Device
    RTE/Device/TM4C123GH6PM/: startup_TM4C123.s system_TM4C123.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
